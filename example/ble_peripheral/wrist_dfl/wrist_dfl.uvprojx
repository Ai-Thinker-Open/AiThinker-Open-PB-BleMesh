# Keil uVision project wrist_dfl.uvprojx, settings and files
target wrist (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.4.5.0
  cpu: IRAM(0x20000000,0x20000) IROM(0x00000000,0x40000) CPUTYPE("Cortex-M0") CLOCK(12000000) ESEL ELITTLE
  output: wrist +hex
  AfterMake: fromelf.exe --bin  -o  ./bin  ./Objects/wrist.axf
  AfterMake: fromelf.exe .\Objects\wrist.axf --i32combined --output .\bin\wrist.hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: CFG_CP CFG_QFN32 CFG_SLEEP_MODE=PWR_MODE_NO_SLEEP DEBUG_INFO=1 DISP_OLED=0 DISP_TFT=2 CFG_DISP=DISP_OLED USE_SYS_TICK=FALSE
  c misc: -DADV_NCONN_CFG=0x01   -DADV_CONN_CFG=0x02   -DSCAN_CFG=0x04    -DINIT_CFG=0x08   -DBROADCASTER_CFG=0x01 -DOBSERVER_CFG=0x02   -DPERIPHERAL_CFG=0x04   -DCENTRAL_CFG=0x08   -DHOST_CONFIG=0x4
  c include: .\Source;..\..\..\components\inc;..\..\..\components\common;..\..\..\components\osal\include;..\..\..\components\ble\include;..\..\..\components\ble\hci;..\..\..\components\ble\host;..\..\..\components\ble\controller\include;..\..\..\components\profiles\DevInfo;..\..\..\components\profiles\GATT;..\..\..\components\profiles\SimpleProfile;..\..\..\components\profiles\Roles;..\..\..\components\profiles\hrs;..\..\..\components\profiles\ota_app;..\..\..\components\driver\common;..\..\..\components\driver\log;..\..\..\components\driver\gpio;..\..\..\components\driver\uart;..\..\..\components\driver\i2c;..\..\..\components\driver\adc;..\..\..\components\driver\clock;..\..\..\components\driver\pwm;..\..\..\components\driver\pwrmgr;..\..\..\components\driver\kscan;..\..\..\components\driver\spi;..\..\..\components\driver\flash;..\..\..\components\driver\watchdog;..\..\..\components\driver\timer;..\..\..\components\libraries\datetime;..\..\..\components\libraries\dfl;..\..\..\components\libraries\crc16;..\..\..\lib;.\Source;.\Source\ui;.\Source\ble;.\Source\epticore
  library: MicroLIB
  memory RVCT4: ROM 0x20000000 size 0x400
  memory RVCT9: RAM 0x1fff6000 size 0x2000
  scatter file: .\scatter_load.sct
  link misc: ..\..\..\misc\rom1Sym.txt --keep=jump_table_base  --keep=global_config --keep=batt_voltage --keep=disp_* --keep=lcd_* --SYMDEFS=appSym.txt
  group arch
    ./Source/: main.c
  group profile
    ../../../components/profiles/DevInfo/: devinfoservice.c
    ../../../components/profiles/GATT/: gattservapp.c
    ../../../components/profiles/Keys/: simplekeys.c
    ../../../components/profiles/Roles/: gap.c gapbondmgr.c gapgattserver.c peripheral.c
    ../../../components/profiles/ota_app/: ota_app_service.c
  group jump
    ../../../misc/: jump_table.c
  group app
    ./Source/: OSAL_wrist.c app_wrist.c wrist_Main.c touch_key.c battery.c KX023.c led_light.c
    ./Source/ble/: wristservice.c
    ./Source/epticore/: em70xx.c M0StaticLib.lib
  group rf
    ../../../lib/: rf.lib
  group driver
    ../../../components/driver/common/: common.c
    ../../../components/driver/log/: my_printf.c
    ../../../components/driver/spi/: spi.c
    ../../../components/driver/uart/: uart.c
    ../../../components/driver/i2c/: i2c.c
    ../../../components/driver/gpio/: gpio.c
    ../../../components/driver/adc/: adc.c
    ../../../components/driver/clock/: clock.c
    ../../../components/driver/pwrmgr/: pwrmgr.c
    ../../../components/driver/pwm/: pwm.c
    ../../../components/driver/kscan/: kscan.c
    ../../../components/driver/flash/: flash.c
  group ui
    ./Source/ui/: lcd_allvision.c res_tab_128x32.c ui_display.c ui_task.c lcd_TFT.c ui_160x80_TFT.c ui_dispTFT.c
  group library
    ../../../components/osal/snv/: osal_snv.c
    ../../../components/libraries/datetime/: app_datetime.c
    ../../../lib/: phy_font.lib
    ../../../components/libraries/dfl/: dfl.c
software components: CMSIS:CORE 4.3.0, Device:Startup 1.0.1
