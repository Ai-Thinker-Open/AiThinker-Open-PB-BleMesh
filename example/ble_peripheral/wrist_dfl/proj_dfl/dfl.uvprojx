# Keil uVision project dfl.uvprojx, settings and files
target wrist (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.5.0.0
  cpu: IRAM(0x20000000,0x20000) IROM(0x00000000,0x40000) CPUTYPE("Cortex-M0") CLOCK(12000000) ESEL ELITTLE
  output: dfl +hex
  BeforeMake: python ..\..\..\..\components\libraries\dfl\dfl_ver.py ..\Objects\appSym.txt
  AfterMake: fromelf.exe --bin  -o  .\bin\  .\Objects\dfl.axf
  AfterMake: fromelf.exe .\Objects\dfl.axf --i32combined --output .\bin\dfl.hex
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: CFG_CP CFG_QFN32 CFG_SLEEP_MODE=PWR_MODE_SLEEP DEBUG_INFO=1 DISP_OLED=0 DISP_TFT=2 CFG_DISP=DISP_OLED USE_SYS_TICK=FALSE UI_STYLE=0
  c misc: -DADV_NCONN_CFG=0x01   -DADV_CONN_CFG=0x02   -DSCAN_CFG=0x04    -DINIT_CFG=0x08   -DBROADCASTER_CFG=0x01 -DOBSERVER_CFG=0x02   -DPERIPHERAL_CFG=0x04   -DCENTRAL_CFG=0x08   -DHOST_CONFIG=0x4
  c include: ..\..\..\..\components\inc;..\..\..\..\components\common;..\..\..\..\components\osal\include;..\..\..\..\components\ble\include;..\..\..\..\components\ble\hci;..\..\..\..\components\ble\host;..\..\..\..\components\ble\controller\include;..\..\..\..\components\profiles\DevInfo;..\..\..\..\components\profiles\GATT;..\..\..\..\components\profiles\SimpleProfile;..\..\..\..\components\profiles\Roles;..\..\..\..\components\profiles\hrs;..\..\..\..\components\profiles\ota_app;..\..\..\..\components\driver\common;..\..\..\..\components\driver\log;..\..\..\..\components\driver\gpio;..\..\..\..\components\driver\uart;..\..\..\..\components\driver\i2c;..\..\..\..\components\driver\adc;..\..\..\..\components\driver\clock;..\..\..\..\components\driver\pwm;..\..\..\..\components\driver\pwrmgr;..\..\..\..\components\driver\kscan;..\..\..\..\components\driver\spi;..\..\..\..\components\driver\flash;..\..\..\..\components\driver\watchdog;..\..\..\..\components\driver\timer;..\..\..\..\components\libraries\datetime;.\..\Source\ui;.\..\Source\ble;.\..\Source\epticore;..\..\..\..\lib;..\proj_dll;..\..\..\..\components\libraries\dfl;..\Source;..\proj_dfl
  library: MicroLIB
  memory RVCT4: ROM 0x20000000 size 0x400
  memory RVCT9: RAM 0x1fff6000 size 0x2000
  scatter file: .\scatter_load.sct
  link misc: ..\Objects\appSym.txt
  group ui
    ../Source/ui/: ui_128x32_normal.c ui_page.c
software components: CMSIS:CORE 4.3.0, Device:Startup 1.0.1
