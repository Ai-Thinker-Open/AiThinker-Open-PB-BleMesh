# Keil uVision project otam.uvprojx, settings and files
target simpleBleCentral Sample (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.5.0.0
  cpu: IRAM(0x20000000,0x20000) IROM(0x00000000,0x40000) CPUTYPE("Cortex-M0") CLOCK(12000000) ESEL ELITTLE
  output: otam
  AfterMake: fromelf.exe --bin -o  ./bin  ./Objects/otam.axf
  AfterMake: fromelf.exe .\Objects\otam.axf --i32combined --output .\bin\otam.hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: CFG_CP CFG_QFN32  DEBUG_INFO=1  CFG_SLEEP_MODE=PWR_MODE_NO_SLEEP
  c misc: -DADV_NCONN_CFG=0x01   -DADV_CONN_CFG=0x02   -DSCAN_CFG=0x04    -DINIT_CFG=0x08   -DBROADCASTER_CFG=0x01 -DOBSERVER_CFG=0x02   -DPERIPHERAL_CFG=0x04   -DCENTRAL_CFG=0x08   -DHOST_CONFIG=0xc
  c include: ..\..\..\components\ble\include;..\..\..\components\inc;..\..\..\components\ble\controller\include;..\..\..\components\ble\hci;..\..\..\components\osal\include;..\..\..\components\inc;..\..\..\components\common;..\..\..\components\ble\host;..\..\..\components\profiles\Roles;..\..\..\components\driver\uart;..\..\..\components\profiles\DevInfo;..\..\..\components\profiles\SimpleProfile;..\..\..\components\driver\common;..\..\..\components\driver\log;..\..\..\components\driver\pwrmgr;..\..\..\components\driver\uart;..\..\..\components\driver\clock;..\..\..\components\driver\gpio;..\..\..\components\driver\adc;..\..\..\components\driver\kscan;..\..\..\components\driver\flash;..\..\..\components\driver\spi;..\..\..\components\driver\i2c;..\..\..\components\driver\timer;..\..\..\components\driver\watchdog;..\..\..\components\driver\kscan;..\..\..\components\libraries\console;..\..\..\lib;.\Source;..\..\..\components\profiles\ota;..\..\..\components\profiles\ota_app;..\..\..\components\libraries\crc16;.\Source\ui
  library: MicroLIB
  memory RVCT4: ROM 0x20000000 size 0x400
  memory RVCT9: RAM 0x1fff6000 size 0x2000
  scatter file: .\scatter_load.sct
  link misc: ..\..\..\misc\rom1Sym.txt --keep=jump_table_base  --keep=global_config
  group arch
    ./Source/: main.c
  group profile
    ../../../components/profiles/DevInfo/: devinfoservice.c
    ../../../components/profiles/Roles/: gap.c gapbondmgr.c gapgattserver.c peripheral.c central.c observer.c
    ../../../components/profiles/Keys/: simplekeys.c
    ../../../components/profiles/GATT/: gattservapp.c
  group jump
    ../../../misc/: jump_table.c
  group app
    ./Source/: OSAL_otaMaster.c ota_master.c otam_cmd.c ota_master_Main.c otam_protocol.c touch_key.c otam_1clk_ota.c
  group rf
    ../../../lib/: rf.lib
  group driver
    ../../../components/driver/clock/: clock.c
    ../../../components/driver/pwrmgr/: pwrmgr.c
    ../../../components/driver/common/: common.c
    ../../../components/driver/gpio/: gpio.c
    ../../../components/driver/uart/: uart.c
    ../../../components/driver/flash/: flash.c
    ../../../components/driver/log/: my_printf.c
    ../../../components/driver/spi/: spi.c
    ../../../components/driver/timer/: ap_timer.c
    ../../../components/driver/watchdog/: watchdog.c
    ../../../components/driver/i2c/: i2c.c
  group library
    ../../../components/osal/snv/: osal_snv.c
    ../../../components/libraries/console/: phy_console.c
  group ui
    ./Source/ui/: lcd_allvision.c res_tab_128x32.c ui_128x32_normal.c ui_display.c ui_task.c
    ../../../lib/: phy_font.lib
software components: CMSIS:CORE 4.3.0, Device:Startup 1.0.1
